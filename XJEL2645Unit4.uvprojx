# Keil uVision project XJEL2645Unit4.uvprojx, settings and files
target XJEL2645Unit4 (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: XJEL2645Unit4
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: TARGET_MCU_STM32 TARGET_STM32L476xG DEVICE_CAN=1 DEVICE_SERIAL_ASYNCH=1 __CORTEX_M4 USE_FULL_LL_DRIVER TARGET_FF_ARDUINO_UNO DEVICE_I2C=1 TOOLCHAIN_ARM TOOLCHAIN_ARM_STD TARGET_LIKE_MBED MBED_DEBUG __FPU_PRESENT=1 DEVICE_SPI_ASYNCH=1 DEVICE_RTC=1 __ASSERT_MSG TARGET_NAME=NUCLEO_L476RG USE_HAL_DRIVER MBED_RAM1_SIZE=0x8000 DEVICE_FLASH=1 DEVICE_ANALOGIN=1 MULADDC_CANNOT_USE_R7 __CMSIS_RTOS DEVICE_WATCHDOG=1 MBED_RAM_SIZE=0x18000 COMPONENT_FLASHIAP=1 MBED_TRAP_ERRORS_ENABLED=1 TARGET_M4 TARGET_CORTEX DEVICE_I2CSLAVE=1 STM32L476xx __MBED_CMSIS_RTOS_CM TARGET_MCU_STM32L476xG TARGET_NUCLEO_L476RG DEVICE_CRC=1 DEVICE_PORTINOUT=1 DEVICE_SPISLAVE=1 DEVICE_PORTOUT=1 DEVICE_ANALOGOUT=1 DEVICE_SERIAL_FC=1 DEVICE_PORTIN=1 EXTRA_IDLE_STACK_REQUIRED DEVICE_USTICKER=1 MBED_RAM_START=0x20000000 TARGET_STM MBED_RAM1_START=0x10000000 DEVICE_MPU=1 DEVICE_SPI=1 __MBED__=1 DEVICE_LPTICKER=1 DEVICE_SERIAL=1 DEVICE_INTERRUPTIN=1 TRANSACTION_QUEUE_SIZE_SPI=2 TOOLCHAIN_ARMC6 DEVICE_SLEEP=1 DEVICE_I2C_ASYNCH=1 TARGET_RTOS_M4_M7 DEVICE_STDIO_MESSAGES=1 TARGET_RELEASE MBED_ROM_SIZE=0x100000 TARGET_LIKE_CORTEX_M4 ARM_MATH_CM4 TARGET_CORTEX_M MBED_MINIMAL_PRINTF MBED_BUILD_TIMESTAMP=1711875491.42 DEVICE_PWMOUT=1 TARGET_MCU_STM32L4 MBED_SPLIT_HEAP DEVICE_TRNG=1 MBED_TICKLESS TARGET_STM32L4 MBED_ROM_START=0x8000000 DEVICE_RESET_REASON=1
  c misc: -DMBED_CONF_PLATFORM_CRASH_CAPTURE_ENABLED=1 -fdata-sections -Wno-deprecated-register -g -c --target=arm-arm-none-eabi -fshort-enums -mcpu=cortex-m4 -fshort-wchar -Wno-armcc-pragma-push-pop -mfpu=fpv4-sp-d16 -Wno-reserved-user-defined-literal -fno-c++-static-destructors -Wno-armcc-pragma-anon-unions -fno-exceptions -mfloat-abi=hard -mthumb -fno-rtti -include mbed_config.h
  c include: .;Core;Core/Inc;mbed-os;mbed-os/cmsis;mbed-os/cmsis/CMSIS_5;mbed-os/cmsis/CMSIS_5/CMSIS;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/Include;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Config;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include1;mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Source;mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;mbed-os/cmsis/device;mbed-os/cmsis/device/RTE;mbed-os/cmsis/device/RTE/include;mbed-os/cmsis/device/rtos;mbed-os/cmsis/device/rtos/include;mbed-os/connectivity;mbed-os/connectivity/cellular;mbed-os/connectivity/cellular/include;mbed-os/connectivity/cellular/include/cellular;mbed-os/connectivity/cellular/include/cellular/framework;mbed-os/connectivity/cellular/include/cellular/framework/API;mbed-os/connectivity/cellular/include/cellular/framework/AT;mbed-os/connectivity/cellular/include/cellular/framework/common;mbed-os/connectivity/cellular/include/cellular/framework/device;mbed-os/connectivity/drivers;mbed-os/connectivity/drivers/802.15.4_RF;mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver/atmel-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver/source;mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver/mcr20a-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver/source;mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver;mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver/source;mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver/stm-s2lp-rf-driver;mbed-os/connectivity/drivers/cellular;mbed-os/connectivity/drivers/cellular/Altair;mbed-os/connectivity/drivers/cellular/Altair/ALT1250;mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP;mbed-os/connectivity/drivers/cellular/GEMALTO;mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION;mbed-os/connectivity/drivers/cellular/GENERIC;mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP;mbed-os/connectivity/drivers/cellular/MultiTech;mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano;mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP;mbed-os/connectivity/drivers/cellular/QUECTEL;mbed-os/connectivity/drivers/cellular/QUECTEL/BC95;mbed-os/connectivity/drivers/cellular/QUECTEL/BG96;mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X;mbed-os/connectivity/drivers/cellular/QUECTEL/M26;mbed-os/connectivity/drivers/cellular/QUECTEL/UG96;mbed-os/connectivity/drivers/cellular/RiotMicro;mbed-os/connectivity/drivers/cellular/RiotMicro/AT;mbed-os/connectivity/drivers/cellular/TELIT;mbed-os/connectivity/drivers/cellular/TELIT/HE910;mbed-os/connectivity/drivers/cellular/TELIT/ME310;mbed-os/connectivity/drivers/cellular/TELIT/ME910;mbed-os/connectivity/drivers/cellular/UBLOX;mbed-os/connectivity/drivers/cellular/UBLOX/AT;mbed-os/connectivity/drivers/cellular/UBLOX/N2XX;mbed-os/connectivity/drivers/cellular/UBLOX/PPP;mbed-os/connectivity/drivers/emac/TARGET_STM;mbed-os/connectivity/drivers/mbedtls/TARGET_STM;mbed-os/connectivity/drivers/nfc;mbed-os/connectivity/drivers/nfc/PN512;mbed-os/connectivity/drivers/nfc/PN512/include;mbed-os/connectivity/drivers/nfc/PN512/include/nfc;mbed-os/connectivity/drivers/nfc/PN512/include/nfc/controllers;mbed-os/connectivity/drivers/nfc/PN512/source;mbed-os/connectivity/drivers/nfc/PN512/source/transceiver;mbed-os/connectivity/drivers/wifi;mbed-os/connectivity/drivers/wifi/esp8266-driver;mbed-os/connectivity/drivers/wifi/esp8266-driver/ESP8266;mbed-os/connectivity/libraries;mbed-os/connectivity/libraries/mbed-coap;mbed-os/connectivity/libraries/mbed-coap/mbed-coap;mbed-os/connectivity/libraries/mbed-coap/source;mbed-os/connectivity/libraries/mbed-coap/source/include;mbed-os/connectivity/libraries/nanostack-libservice;mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice;mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice/platform;mbed-os/connectivity/libraries/ppp;mbed-os/connectivity/libraries/ppp/include;mbed-os/connectivity/libraries/ppp/include/polarssl;mbed-os/connectivity/libraries/ppp/include/ppp;mbed-os/connectivity/lorawan;mbed-os/connectivity/lorawan/include;mbed-os/connectivity/lorawan/include/lorawan;mbed-os/connectivity/lorawan/lorastack;mbed-os/connectivity/lorawan/lorastack/mac;mbed-os/connectivity/lorawan/lorastack/phy;mbed-os/connectivity/lorawan/system;mbed-os/connectivity/lwipstack;mbed-os/connectivity/lwipstack/include;mbed-os/connectivity/lwipstack/include/lwipstack;mbed-os/connectivity/lwipstack/lwip;mbed-os/connectivity/lwipstack/lwip-sys;mbed-os/connectivity/lwipstack/lwip-sys/arch;mbed-os/connectivity/lwipstack/lwip/src;mbed-os/connectivity/lwipstack/lwip/src/include;mbed-os/connectivity/lwipstack/lwip/src/include/compat;mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix;mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/arpa;mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/net;mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/sys;mbed-os/connectivity/lwipstack/lwip/src/include/lwip;mbed-os/connectivity/lwipstack/lwip/src/include/lwip/priv;mbed-os/connectivity/lwipstack/lwip/src/include/lwip/prot;mbed-os/connectivity/lwipstack/lwip/src/include/netif;mbed-os/connectivity/mbedtls;mbed-os/connectivity/mbedtls/include;mbed-os/connectivity/mbedtls/include/mbedtls;mbed-os/connectivity/mbedtls/platform;mbed-os/connectivity/mbedtls/platform/inc;mbed-os/connectivity/mbedtls/source;mbed-os/connectivity/nanostack;mbed-os/connectivity/nanostack/coap-service;mbed-os/connectivity/nanostack/coap-service/coap-service;mbed-os/connectivity/nanostack/coap-service/source;mbed-os/connectivity/nanostack/coap-service/source/include;mbed-os/connectivity/nanostack/include;mbed-os/connectivity/nanostack/include/nanostack-interface;mbed-os/connectivity/nanostack/mbed-mesh-api;mbed-os/connectivity/nanostack/mbed-mesh-api/mbed-mesh-api;mbed-os/connectivity/nanostack/mbed-mesh-api/source;mbed-os/connectivity/nanostack/mbed-mesh-api/source/include;mbed-os/connectivity/nanostack/nanostack-hal-mbed-cmsis-rtos;mbed-os/connectivity/nanostack/sal-stack-nanostack;mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop;mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop;mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/platform;mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop/source;mbed-os/connectivity/nanostack/sal-stack-nanostack/nanostack;mbed-os/connectivity/nanostack/sal-stack-nanostack/nanostack/platform;mbed-os/connectivity/nanostack/sal-stack-nanostack/source;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Fragmentation;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/IPHC_Decode;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/MAC;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Mesh;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/ND;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/NVM;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Thread;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/ws;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/BorderRouter;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Common_Protocols;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Core;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Core/include;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/DHCPv6_Server;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/DHCPv6_client;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/IEEE802_15_4;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/virtual_rf;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MLE;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MPL;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/NWK_INTERFACE;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/Include;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/RPL;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/Common;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/PANA;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/TLS;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/eapol;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/kmp;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/eap_tls_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/fwh_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/gkh_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/key_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/msg_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/radius_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/tls_sec_prot;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/Neighbor_cache;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/Trickle;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/blacklist;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/etx;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/fhss;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/fnv_hash;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/hmac;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/ieee_802_11;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/load_balance;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mac_neighbor_table;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/compiler;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/cpu;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/dns;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/mdns;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/poll;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/serial;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/stack;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mle_service;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/nd_proxy;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/nist_aes_kw;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/pan_blacklist;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/random_early_detection;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/utils;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/whiteboard;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/configs;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/configs/base;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/ipv6_stack;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/libDHCPv6;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/libNET;mbed-os/connectivity/nanostack/sal-stack-nanostack/source/libNET/src;mbed-os/connectivity/netsocket;mbed-os/connectivity/netsocket/include;mbed-os/connectivity/netsocket/include/netsocket;mbed-os/connectivity/nfc;mbed-os/connectivity/nfc/include;mbed-os/connectivity/nfc/include/nfc;mbed-os/connectivity/nfc/include/nfc/ndef;mbed-os/connectivity/nfc/include/nfc/ndef/common;mbed-os/connectivity/nfc/libraries;mbed-os/connectivity/nfc/libraries/acore;mbed-os/connectivity/nfc/libraries/acore/acore;mbed-os/connectivity/nfc/libraries/stack;mbed-os/connectivity/nfc/libraries/stack/ndef;mbed-os/connectivity/nfc/libraries/stack/platform;mbed-os/connectivity/nfc/libraries/stack/tech;mbed-os/connectivity/nfc/libraries/stack/tech/iso7816;mbed-os/connectivity/nfc/libraries/stack/tech/isodep;mbed-os/connectivity/nfc/libraries/stack/tech/type4;mbed-os/connectivity/nfc/libraries/stack/transceiver;mbed-os/drivers;mbed-os/drivers/device_key;mbed-os/drivers/device_key/include;mbed-os/drivers/device_key/include/device_key;mbed-os/drivers/include;mbed-os/drivers/include/drivers;mbed-os/drivers/include/drivers/interfaces;mbed-os/drivers/usb;mbed-os/drivers/usb/include;mbed-os/drivers/usb/include/usb;mbed-os/drivers/usb/include/usb/internal;mbed-os/events;mbed-os/events/include;mbed-os/events/include/events;mbed-os/events/include/events/internal;mbed-os/features;mbed-os/features/frameworks;mbed-os/features/frameworks/greentea-client;mbed-os/features/frameworks/greentea-client/greentea-client;mbed-os/features/frameworks/mbed-client-cli;mbed-os/features/frameworks/mbed-client-cli/mbed-client-cli;mbed-os/features/frameworks/unity;mbed-os/features/frameworks/unity/unity;mbed-os/features/frameworks/utest;mbed-os/features/frameworks/utest/utest;mbed-os/hal;mbed-os/hal/include;mbed-os/hal/include/hal;mbed-os/hal/usb;mbed-os/hal/usb/include;mbed-os/hal/usb/include/usb;mbed-os/platform;mbed-os/platform/cxxsupport;mbed-os/platform/include;mbed-os/platform/include/platform;mbed-os/platform/include/platform/internal;mbed-os/platform/mbed-trace;mbed-os/platform/mbed-trace/include;mbed-os/platform/mbed-trace/include/mbed-trace;mbed-os/platform/randlib;mbed-os/platform/randlib/include;mbed-os/platform/randlib/include/mbed-client-randlib;mbed-os/platform/randlib/include/mbed-client-randlib/platform;mbed-os/platform/source;mbed-os/platform/source/minimal-printf;mbed-os/rtos;mbed-os/rtos/include;mbed-os/rtos/include/rtos;mbed-os/rtos/include/rtos/internal;mbed-os/rtos/source;mbed-os/storage;mbed-os/storage/blockdevice;mbed-os/storage/blockdevice/COMPONENT_FLASHIAP;mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/include;mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/include/FlashIAP;mbed-os/storage/blockdevice/include;mbed-os/storage/blockdevice/include/blockdevice;mbed-os/storage/blockdevice/include/blockdevice/internal;mbed-os/storage/filesystem;mbed-os/storage/filesystem/fat;mbed-os/storage/filesystem/fat/ChaN;mbed-os/storage/filesystem/fat/include;mbed-os/storage/filesystem/fat/include/fat;mbed-os/storage/filesystem/include;mbed-os/storage/filesystem/include/filesystem;mbed-os/storage/filesystem/littlefs;mbed-os/storage/filesystem/littlefs/include;mbed-os/storage/filesystem/littlefs/include/littlefs;mbed-os/storage/filesystem/littlefs/littlefs;mbed-os/storage/filesystem/littlefsv2;mbed-os/storage/filesystem/littlefsv2/include;mbed-os/storage/filesystem/littlefsv2/include/littlefsv2;mbed-os/storage/filesystem/littlefsv2/littlefs;mbed-os/storage/kvstore;mbed-os/storage/kvstore/direct_access_devicekey;mbed-os/storage/kvstore/direct_access_devicekey/include;mbed-os/storage/kvstore/direct_access_devicekey/include/direct_access_devicekey;mbed-os/storage/kvstore/filesystemstore;mbed-os/storage/kvstore/filesystemstore/include;mbed-os/storage/kvstore/filesystemstore/include/filesystemstore;mbed-os/storage/kvstore/include;mbed-os/storage/kvstore/include/kvstore;mbed-os/storage/kvstore/kv_config;mbed-os/storage/kvstore/kv_config/include;mbed-os/storage/kvstore/kv_config/include/kv_config;mbed-os/storage/kvstore/kvstore_global_api;mbed-os/storage/kvstore/kvstore_global_api/include;mbed-os/storage/kvstore/kvstore_global_api/include/kvstore_global_api;mbed-os/storage/kvstore/securestore;mbed-os/storage/kvstore/securestore/include;mbed-os/storage/kvstore/securestore/include/securestore;mbed-os/storage/kvstore/tdbstore;mbed-os/storage/kvstore/tdbstore/include;mbed-os/storage/kvstore/tdbstore/include/tdbstore;mbed-os/targets/TARGET_STM;mbed-os/targets/TARGET_STM/TARGET_STM32L4;mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW;mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS;mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver;mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy;mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG;mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG;E:/Projects/School/XJEL2645Unit4/mbed-os;.\Thirdparty\Joystick;.\Thirdparty\N5110;.\Thirdparty\CMSIS_Math\Include;.\Thirdparty\MatrixLibrary
  asm misc: --cpreproc --cpreproc_opts=-DMBED_CONF_PLATFORM_CRASH_CAPTURE_ENABLED=1,-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSE_FULL_LL_DRIVER,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DSTM32L476xx,-DMBED_SPLIT_HEAP,-D__MBED_CMSIS_RTOS_CM,-DEXTRA_IDLE_STACK_REQUIRED,-D__CMSIS_RTOS,-DMBED_TICKLESS,-DUSE_HAL_DRIVER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TOOLCHAIN_ARM/stm32l476xg.sct
  link misc: --cpu=Cortex-M4 --predefine="-DMBED_BOOT_STACK_SIZE=1024" --remove --predefine="-DMBED_RAM_SIZE=0x18000" --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DMBED_RAM_START=0x20000000" --predefine="-DMBED_ROM_SIZE=0x100000" --predefine="-DXIP_ENABLE=0" --verbose --any_contingency --predefine="-DMBED_RAM1_START=0x10000000" --show_full_path --predefine="-DMBED_RAM1_SIZE=0x8000" --keep=os_cb_sections --legacyalign
  group Core/Src
    ./Core/Src/: main.cpp 3DEngine.cpp
  group Thirdparty/N5110
    ./Thirdparty/N5110/: Bitmap.cpp Bitmap.h N5110.cpp N5110.h
  group Thirdparty/Joystick
    ./Thirdparty/Joystick/: Joystick.cpp
  group mbed-os
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/IPHC_Decode/: 6lowpan_iphc.c cipv6.h iphc_compress.c iphc_compress.h iphc_decompress.c iphc_decompress.h lowpan_context.c lowpan_context.h
    ./mbed-os/connectivity/nfc/libraries/acore/source/: ac_buffer.c ac_buffer_builder.c ac_buffer_reader.c ac_stream.c
    ./mbed-os/connectivity/nfc/libraries/acore/acore/: ac_buffer.h ac_buffer_builder.h ac_buffer_reader.h ac_debug.h ac_macros.h ac_stream.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/: adaptation_interface.c lowpan_adaptation_interface.h
    ./mbed-os/connectivity/mbedtls/source/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_invasive.h ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c ssl_tls13_keys.h threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ./mbed-os/connectivity/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h common.h compat-1.3.h config-no-entropy.h config.h config_psa.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h psa_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    ./mbed-os/connectivity/drivers/mbedtls/TARGET_STM/: aes_alt.cpp aes_alt.h aes_alt_stm32l4.c aes_alt_stm32l4.h ccm_alt.cpp ccm_alt.h cryp_stm32.c cryp_stm32.h gcm_alt.cpp gcm_alt.h hash_stm32.c hash_stm32.h md5_alt.cpp md5_alt.h sha1_alt.cpp sha1_alt.h sha256_alt.cpp sha256_alt.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/mbedOS/: aes_mbedtls_adapter.c
    ./mbed-os/connectivity/drivers/cellular/Altair/ALT1250/PPP/: ALT1250_PPP.cpp ALT1250_PPP.h ALT1250_PPP_CellularContext.cpp ALT1250_PPP_CellularContext.h ALT1250_PPP_CellularNetwork.cpp ALT1250_PPP_CellularNetwork.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h lwip_errno.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
    ./mbed-os/drivers/source/: AnalogIn.cpp AnalogOut.cpp BufferedSerial.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp DigitalIn.cpp DigitalInOut.cpp DigitalOut.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp MbedCRC.cpp OSPI.cpp PortIn.cpp PortInOut.cpp PortOut.cpp PwmOut.cpp QSPI.cpp ResetReason.cpp SerialBase.cpp SerialWireOutput.cpp SPI.cpp SPISlave.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UnbufferedSerial.cpp Watchdog.cpp
    ./mbed-os/drivers/include/drivers/: AnalogIn.h AnalogOut.h BufferedSerial.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h FlashIAP.h HighResClock.h I2C.h I2CSlave.h InterruptIn.h LowPowerClock.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h OSPI.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawCAN.h RealTimeClock.h ResetReason.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Ticker.h TickerDataClock.h Timeout.h Timer.h TimerEvent.h UnbufferedSerial.h Watchdog.h
    ./mbed-os/targets/TARGET_STM/: analogin_api.c analogout_api.c can_api.c device.h gpio_api.c gpio_irq_api.c gpio_object.h hal_tick_overrides.c i2c_api.c lp_ticker.c lp_ticker_defines.h mbed_crc_api.c mbed_overrides.c mbed_rtx.h nvic_addr.h ospi_api.c PeripheralPins.h pinmap.c PinNamesTypes.h port_api.c PortNames.h pwmout_api.c qspi_api.c reset_reason.c rtc_api.c rtc_api_hal.h serial_api.c serial_api_hal.h sleep.c stm32_assert.h stm_i2c_api.h stm_spi_api.c trng_api.c us_ticker.c us_ticker_defines.h USBPhy_STM32.cpp USBPhyHw.h watchdog_api.c
    ./mbed-os/hal/include/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h ospi_api.h pinmap.h PinNameAliases.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/: analogin_device.c analogout_device.c can_device.h cmsis.h flash_api.c gpio_irq_device.c gpio_irq_device.h i2c_device.c i2c_device.h objects.h PeripheralNames.h pin_device.h pwmout_device.c pwmout_device.h serial_device.c spi_api.c spi_device.h us_ticker_data.h
    ./mbed-os/connectivity/cellular/source/framework/common/: APN_db.cpp CellularLog.cpp CellularUtil.cpp
    ./mbed-os/connectivity/cellular/include/cellular/framework/common/: APN_db.h CellularCommon.h CellularList.h CellularLog.h CellularUtil.h
    ./mbed-os/connectivity/libraries/ppp/include/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/nanostack/platform/: arm_hal_aes.h arm_hal_phy.h os_whiteboard.h topo_trace.h
    ./mbed-os/connectivity/nanostack/nanostack-hal-mbed-cmsis-rtos/: arm_hal_fhss_timer.cpp arm_hal_interrupt.c arm_hal_interrupt_private.h arm_hal_random.c arm_hal_timer.cpp ns_event_loop.c ns_event_loop.h ns_event_loop_mbed.cpp ns_event_loop_mutex.c ns_event_loop_mutex.h ns_file_system_api.cpp ns_file_system_api.h ns_hal_init.c ns_hal_init.h
    ./mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    ./mbed-os/platform/randlib/include/mbed-client-randlib/platform/: arm_hal_random.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
    ./mbed-os/drivers/usb/source/: AsyncOp.cpp ByteBuffer.cpp EndpointResolver.cpp LinkedListBase.cpp OperationListBase.cpp PolledQueue.cpp TaskBase.cpp USBAudio.cpp USBCDC.cpp USBCDC_ECM.cpp USBDevice.cpp USBHID.cpp USBKeyboard.cpp USBMIDI.cpp USBMouse.cpp USBMouseKeyboard.cpp USBMSD.cpp USBSerial.cpp
    ./mbed-os/drivers/usb/include/usb/internal/: AsyncOp.h ByteBuffer.h EndpointResolver.h LinkedList.h LinkedListBase.h LinkEntry.h MIDIMessage.h OperationList.h OperationListBase.h PolledQueue.h Task.h TaskBase.h TaskQueue.h USBAudio_Types.h USBDescriptor.h USBDevice.h USBDevice_Types.h USBHID_Types.h
    ./mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver/source/: at24mac.cpp at24mac.h AT86RF215Reg.h AT86RFReg.h NanostackRfPhyAT86RF215.cpp NanostackRfPhyAtmel.cpp rfbits.h
    ./mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver/source/: at24mac_s2lp.cpp at24mac_s2lp.h NanostackRfPhys2lp.cpp rf_configuration.c rf_configuration.h s2lpReg.h
    ./mbed-os/connectivity/cellular/source/framework/AT/: AT_CellularContext.cpp AT_CellularDevice.cpp AT_CellularInformation.cpp AT_CellularNetwork.cpp AT_CellularSMS.cpp AT_CellularStack.cpp AT_ControlPlane_netif.cpp
    ./mbed-os/connectivity/cellular/include/cellular/framework/AT/: AT_CellularContext.h AT_CellularDevice.h AT_CellularInformation.h AT_CellularNetwork.h AT_CellularSMS.h AT_CellularStack.h AT_ControlPlane_netif.h
    ./mbed-os/platform/source/: ATCmdParser.cpp CriticalSectionLock.cpp CThunkBase.cpp DeepSleepLock.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_atomic_impl.c mbed_board.c mbed_crash_data_offsets.h mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mem_trace.cpp mbed_mktime.c mbed_mpu_mgmt.c mbed_os_timer.cpp mbed_poll.cpp mbed_power_mgmt.c mbed_retarget.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_thread.cpp mbed_wait_api_no_rtos.c newlib_nano_malloc_workaround.c Stream.cpp SysTimer.cpp
    ./mbed-os/platform/include/platform/: ATCmdParser.h Callback.h CircularBuffer.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_chrono.h mbed_critical.h mbed_debug.h mbed_enum_flags.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h
    ./mbed-os/connectivity/cellular/source/framework/device/: ATHandler.cpp CellularContext.cpp CellularDevice.cpp CellularStateMachine.cpp
    ./mbed-os/connectivity/cellular/include/cellular/framework/API/: ATHandler.h CellularContext.h CellularDevice.h CellularInformation.h CellularNetwork.h CellularSMS.h
    ./mbed-os/connectivity/libraries/ppp/source/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c ppp_ecp.c ppp_service.cpp ppp_service_if.cpp pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.cpp upap.c utils.c vj.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/eap_tls_sec_prot/: auth_eap_tls_sec_prot.c auth_eap_tls_sec_prot.h eap_tls_sec_prot_lib.c eap_tls_sec_prot_lib.h radius_eap_tls_sec_prot.c radius_eap_tls_sec_prot.h supp_eap_tls_sec_prot.c supp_eap_tls_sec_prot.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/fwh_sec_prot/: auth_fwh_sec_prot.c auth_fwh_sec_prot.h supp_fwh_sec_prot.c supp_fwh_sec_prot.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/gkh_sec_prot/: auth_gkh_sec_prot.c auth_gkh_sec_prot.h supp_gkh_sec_prot.c supp_gkh_sec_prot.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/radius_sec_prot/: avp_helper.c avp_helper.h radius_client_sec_prot.c radius_client_sec_prot.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/MAC/: beacon_handler.c beacon_handler.h mac_data_poll.c mac_data_poll.h mac_helper.c mac_helper.h mac_ie_lib.c mac_ie_lib.h mac_pairwise_key.c mac_pairwise_key.h mac_response_handler.c mac_response_handler.h mpx_api.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/blacklist/: blacklist.c blacklist.h
    ./mbed-os/storage/blockdevice/include/blockdevice/: BlockDevice.h BufferedBlockDevice.h ChainingBlockDevice.h ExhaustibleBlockDevice.h FlashSimBlockDevice.h HeapBlockDevice.h MBRBlockDevice.h ObservingBlockDevice.h ProfilingBlockDevice.h ReadOnlyBlockDevice.h SlicingBlockDevice.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/BorderRouter/: border_router.c border_router.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Core/: buffer_dyn.c ns_address_internal.c ns_monitor.c ns_socket.c sockbuf.c
    ./mbed-os/storage/blockdevice/source/: BufferedBlockDevice.cpp ChainingBlockDevice.cpp ExhaustibleBlockDevice.cpp FlashSimBlockDevice.cpp HeapBlockDevice.cpp MBRBlockDevice.cpp ObservingBlockDevice.cpp ProfilingBlockDevice.cpp ReadOnlyBlockDevice.cpp SFDP.cpp SlicingBlockDevice.cpp
    ./mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ./mbed-os/connectivity/nanostack/mbed-mesh-api/source/include/: callback_handler.h enet_tasklet.h mesh_system.h NanostackMemoryManager.h nd_tasklet.h thread_tasklet.h wisun_tasklet.h
    ./mbed-os/connectivity/nanostack/mbed-mesh-api/source/: CallbackHandler.cpp ethernet_tasklet.c LoWPANNDInterface.cpp mesh_system.c MeshInterfaceNanostack.cpp NanostackEMACInterface.cpp NanostackEthernetInterface.cpp NanostackMemoryManager.cpp NanostackPPPInterface.cpp nd_tasklet.c thread_tasklet.c ThreadInterface.cpp wisun_tasklet.c WisunBorderRouter.cpp WisunInterface.cpp
    ./mbed-os/connectivity/lwipstack/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/nanostack/: cca_api.h ccmLIB.h dhcp_service_api.h ethernet_mac_api.h fhss_api.h fhss_config.h fhss_test_api.h fhss_ws_extension.h mac_api.h mac_common_defines.h mac_filter_api.h mac_mcps.h mlme.h multicast_api.h net_6lowpan_parameter_api.h net_address_extension.h net_fhss.h net_interface.h net_ipv6_api.h net_load_balance_api.h net_mle_api.h net_nvm_api.h net_nwk_scan.h net_pana_parameters_api.h net_polling_api.h net_rpl.h net_sleep.h net_test_api.h net_thread_test.h net_ws_test.h net_ws_test_ext.h ns_address.h ns_conf.h ns_file_system.h ns_mdns_api.h ns_sha256.h ns_time_api.h ns_virtual_rf_api.h nwk_stats_api.h serial_mac_api.h shalib.h socket_api.h sw_mac.h thread_bbr_api.h thread_border_router_api.h thread_commissioning_api.h thread_dhcpv6_server.h thread_diagcop_lib.h thread_lowpower_api.h thread_management_api.h thread_management_if.h thread_meshcop_lib.h thread_net_config_api.h whiteboard_api.h ws_bbr_api.h ws_management_api.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/: ccm_security.c
    ./mbed-os/connectivity/libraries/ppp/include/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h ppp_service.h ppp_service_if.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    ./mbed-os/connectivity/netsocket/include/netsocket/: CellularInterface.h CellularNonIPSocket.h ControlPlane_netif.h DNS.h DTLSSocket.h DTLSSocketWrapper.h EMAC.h EMACInterface.h EMACMemoryManager.h EthernetInterface.h EthInterface.h ICMPSocket.h InternetDatagramSocket.h InternetSocket.h L3IP.h L3IPInterface.h MeshInterface.h MsgHeader.h NetStackMemoryManager.h NetworkInterface.h NetworkStack.h nsapi.h nsapi_dns.h nsapi_ppp.h nsapi_types.h OnboardNetworkStack.h PPP.h PPPInterface.h Socket.h SocketAddress.h SocketStats.h TCPSocket.h TLSSocket.h TLSSocketWrapper.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h
    ./mbed-os/connectivity/netsocket/source/: CellularNonIPSocket.cpp DTLSSocket.cpp DTLSSocketWrapper.cpp EMACInterface.cpp EthernetInterface.cpp ICMPSocket.cpp InternetDatagramSocket.cpp InternetSocket.cpp L3IPInterface.cpp NetStackMemoryManager.cpp NetworkInterface.cpp NetworkInterfaceDefaults.cpp NetworkStack.cpp nsapi_dns.cpp nsapi_ppp.cpp PPPInterface.cpp SocketAddress.cpp SocketStats.cpp TCPSocket.cpp TLSSocket.cpp TLSSocketWrapper.cpp UDPSocket.cpp WiFiAccessPoint.cpp
    ./mbed-os/connectivity/cellular/include/cellular/framework/device/: CellularStateMachine.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/configs/base/: cfg_ethernet.h cfg_local_socket.h cfg_lowpan_border_router.h cfg_lowpan_host.h cfg_lowpan_router.h cfg_rf_tunnel.h cfg_thread_border_router.h cfg_thread_end_device.h cfg_thread_full_end_device.h cfg_thread_router.h cfg_ws_border_router.h cfg_ws_full.h cfg_ws_host.h cfg_ws_router.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/configs/: cfg_ethernet_host.h cfg_generic.h cfg_lowpan_border_router.h cfg_lowpan_border_router_rf_tunnel.h cfg_lowpan_border_router_rf_tunnel_ecc.h cfg_lowpan_border_router_rf_tunnel_ecc_release.h cfg_lowpan_host.h cfg_lowpan_router.h cfg_lowpan_router_ecc.h cfg_lowpan_router_ecc_release.h cfg_nanostack_full.h cfg_nanostack_full_debug.h cfg_rf_interface.h cfg_thread_border_router.h cfg_thread_end_device.h cfg_thread_full_end_device.h cfg_thread_router.h cfg_thread_thci.h cfg_ws_border_router.h cfg_ws_full.h cfg_ws_host.h cfg_ws_router.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/fhss/: channel_functions.c channel_functions.h channel_list.c channel_list.h fhss.c fhss.h fhss_channel.c fhss_channel.h fhss_common.c fhss_common.h fhss_configuration_interface.c fhss_statistics.c fhss_statistics.h fhss_test_api.c fhss_ws.c fhss_ws.h fhss_ws_empty_functions.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Fragmentation/: cipv6_fragmenter.c cipv6_fragmenter.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/: cmsis_nvic.h system_clock.c
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include1/: cmsis_os.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Library/: cmsis_os1.c
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/Include/: cmsis_os2.h os_tick.h
    ./mbed-os/connectivity/nanostack/coap-service/source/: coap_connection_handler.c coap_message_handler.c coap_security_handler.c coap_service_api.c
    ./mbed-os/connectivity/nanostack/coap-service/source/include/: coap_connection_handler.h coap_message_handler.h coap_security_handler.h coap_service_api_internal.h
    ./mbed-os/connectivity/nanostack/coap-service/coap-service/: coap_service_api.h
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/libBits/: common_functions.c
    ./mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice/: common_functions.h ip4string.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_types.h nsdynmem_tracker.h nsdynmem_tracker_lib.h nsdynmemLIB.h
    ./mbed-os/rtos/source/: ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp rtos_handlers.h rtos_idle.h Semaphore.cpp ThisThread.cpp Thread.cpp
    ./mbed-os/rtos/include/rtos/: ConditionVariable.h EventFlags.h Kernel.h Mail.h mbed_rtos_types.h MemoryPool.h Mutex.h Queue.h rtos.h Semaphore.h ThisThread.h Thread.h
    ./mbed-os/platform/include/platform/internal/: CThunkBase.h mbed_atomic_impl.h mbed_error_hist.h mbed_fault_handler.h mbed_os_timer.h SysTimer.h
    ./mbed-os/drivers/device_key/source/: DeviceKey.cpp
    ./mbed-os/drivers/device_key/include/device_key/: DeviceKey.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/libDHCPv6/: dhcp_service_api.c libDHCPv6.c libDHCPv6.h libDHCPv6_server.c libDHCPv6_server.h libDHCPv6_vendordata.c libDHCPv6_vendordata.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/DHCPv6_client/: dhcpv6_client_api.h dhcpv6_client_service.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/DHCPv6_Server/: DHCPv6_Server_service.c DHCPv6_server_service.h
    ./mbed-os/storage/filesystem/source/: Dir.cpp File.cpp FileSystem.cpp
    ./mbed-os/storage/filesystem/include/filesystem/: Dir.h File.h FileSystem.h mbed_filesystem.h
    ./mbed-os/storage/kvstore/direct_access_devicekey/source/: DirectAccessDevicekey.cpp
    ./mbed-os/storage/kvstore/direct_access_devicekey/include/direct_access_devicekey/: DirectAccessDevicekey.h
    ./mbed-os/storage/filesystem/fat/ChaN/: diskio.h ff.cpp ff.h ffconf.h ffunicode.cpp integer.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/PANA/: eap_protocol.c eap_protocol.h pana.c pana.h pana_avp.c pana_avp.h pana_client.c pana_eap_header.c pana_eap_header.h pana_header.c pana_header.h pana_internal_api.h pana_nvm.h pana_relay_table.c pana_relay_table.h pana_server.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/eapol/: eapol_helper.c eapol_helper.h kde_helper.c kde_helper.h
    ./mbed-os/events/source/: equeue.c equeue_mbed.cpp equeue_posix.c EventQueue.cpp mbed_shared_queues.cpp
    ./mbed-os/events/include/events/: equeue.h Event.h EventQueue.h mbed_events.h mbed_shared_queues.h UserAllocatedEvent.h
    ./mbed-os/events/include/events/internal/: equeue_platform.h
    ./mbed-os/connectivity/drivers/wifi/esp8266-driver/ESP8266/: ESP8266.cpp ESP8266.h
    ./mbed-os/connectivity/drivers/wifi/esp8266-driver/: ESP8266Interface.cpp ESP8266Interface.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/ethernet/: ethernet_mac_api.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/etx/: etx.c etx.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop/source/: event.c event.h ns_timeout.c ns_timer.c ns_timer.h system_timer.c timer_sys.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ./mbed-os/storage/filesystem/fat/source/: FATFileSystem.cpp
    ./mbed-os/storage/filesystem/fat/include/fat/: FATFileSystem.h
    ./mbed-os/storage/kvstore/filesystemstore/source/: FileSystemStore.cpp
    ./mbed-os/storage/kvstore/filesystemstore/include/filesystemstore/: FileSystemStore.h
    ./mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/source/: FlashIAPBlockDevice.cpp
    ./mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/include/FlashIAP/: FlashIAPBlockDevice.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/: fnet.h fnet_config.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/stack/: fnet_arp.h fnet_assert.h fnet_debug.h fnet_error.h fnet_eth.h fnet_icmp6.h fnet_inet.h fnet_ip.h fnet_ip6.h fnet_isr.h fnet_mempool.h fnet_nd6.h fnet_netbuf.h fnet_netif.h fnet_netif_prv.h fnet_socket.h fnet_stack.h fnet_stack_config.h fnet_stdlib.c fnet_stdlib.h fnet_timer.h fnet_timer_prv.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/compiler/: fnet_comp.h fnet_comp_config.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/cpu/: fnet_cpu.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/dns/: fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/mdns/: fnet_mdns.c fnet_mdns.h fnet_mdns_config.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/poll/: fnet_poll.c fnet_poll.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/serial/: fnet_serial.h fnet_serial_config.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/: fnet_services.h fnet_services_config.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/: fnet_user_config.h ns_fnet_events.c ns_fnet_events.h ns_fnet_port.c ns_fnet_types.h ns_mdns_api.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/fnv_hash/: fnv_hash.c fnv_hash.h
    ./mbed-os/connectivity/drivers/cellular/GEMALTO/CINTERION/: GEMALTO_CINTERION.cpp GEMALTO_CINTERION.h GEMALTO_CINTERION_CellularContext.cpp GEMALTO_CINTERION_CellularContext.h GEMALTO_CINTERION_CellularInformation.cpp GEMALTO_CINTERION_CellularInformation.h GEMALTO_CINTERION_CellularStack.cpp GEMALTO_CINTERION_CellularStack.h
    ./mbed-os/connectivity/drivers/cellular/GENERIC/GENERIC_AT3GPP/: GENERIC_AT3GPP.cpp GENERIC_AT3GPP.h
    ./mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_test_env.cpp
    ./mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h test_env.h
    ./mbed-os/connectivity/mbedtls/platform/src/: hash_wrappers.c mbed_trng.cpp platform_alt.cpp shared_rng.cpp timing_mbed.cpp
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/hmac/: hmac_md.c hmac_md.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Common_Protocols/: icmpv6.c icmpv6.h icmpv6_prefix.c icmpv6_prefix.h icmpv6_radv.c icmpv6_radv.h ip.h ipv6.c ipv6.h ipv6_constants.h ipv6_flow.c ipv6_flow.h ipv6_fragmentation.c ipv6_fragmentation.h ipv6_resolution.c ipv6_resolution.h mld.c mld.h tcp.c tcp.h udp.c udp.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/ieee_802_11/: ieee_802_11.c ieee_802_11.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/net/: if.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/arpa/: inet.h
    ./mbed-os/drivers/include/drivers/interfaces/: InterfaceCAN.h InterfaceDigitalIn.h InterfaceDigitalInOut.h InterfaceDigitalOut.h
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/libip4string/: ip4tos.c stoip4.c
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/ipv6_stack/: ipv6_routing_table.c ipv6_routing_table.h protocol_ipv6.c protocol_ipv6.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: irq_cm4f.S
    ./mbed-os/connectivity/nfc/libraries/stack/tech/iso7816/: iso7816.c iso7816.h iso7816_app.c iso7816_app.h iso7816_defs.h
    ./mbed-os/connectivity/nfc/libraries/stack/tech/isodep/: isodep.h isodep_target.c isodep_target.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/utils/: isqrt.c isqrt.h ns_conf.c ns_crc.c ns_crc.h ns_file.h ns_file_system.c ns_time.c ns_time.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/key_sec_prot/: key_sec_prot.c key_sec_prot.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/kmp/: kmp_addr.c kmp_addr.h kmp_api.c kmp_api.h kmp_eapol_pdu_if.c kmp_eapol_pdu_if.h kmp_socket_if.c kmp_socket_if.h
    ./mbed-os/storage/kvstore/kv_config/source/: kv_config.cpp
    ./mbed-os/storage/kvstore/kv_config/include/kv_config/: kv_config.h
    ./mbed-os/storage/kvstore/kvstore_global_api/source/: KVMap.cpp kvstore_global_api.cpp
    ./mbed-os/storage/kvstore/kvstore_global_api/include/kvstore_global_api/: KVMap.h kvstore_global_api.h
    ./mbed-os/storage/kvstore/include/kvstore/: KVStore.h
    ./mbed-os/storage/filesystem/littlefs/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
    ./mbed-os/storage/filesystem/littlefsv2/littlefs/: lfs2.c lfs2.h lfs2_util.c lfs2_util.h
    ./mbed-os/storage/filesystem/littlefs/source/: LittleFileSystem.cpp
    ./mbed-os/storage/filesystem/littlefs/include/littlefs/: LittleFileSystem.h
    ./mbed-os/storage/filesystem/littlefsv2/source/: LittleFileSystem2.cpp
    ./mbed-os/storage/filesystem/littlefsv2/include/littlefsv2/: LittleFileSystem2.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/load_balance/: load_balance.c load_balance_api.h
    ./mbed-os/connectivity/lorawan/lorastack/phy/: lora_phy_ds.h LoRaPHY.cpp LoRaPHY.h loraphy_target.h LoRaPHYAS923.cpp LoRaPHYAS923.h LoRaPHYAU915.cpp LoRaPHYAU915.h LoRaPHYCN470.cpp LoRaPHYCN470.h LoRaPHYCN779.cpp LoRaPHYCN779.h LoRaPHYEU433.cpp LoRaPHYEU433.h LoRaPHYEU868.cpp LoRaPHYEU868.h LoRaPHYIN865.cpp LoRaPHYIN865.h LoRaPHYKR920.cpp LoRaPHYKR920.h LoRaPHYUS915.cpp LoRaPHYUS915.h
    ./mbed-os/connectivity/lorawan/lorastack/mac/: LoRaMac.cpp LoRaMac.h LoRaMacChannelPlan.cpp LoRaMacChannelPlan.h LoRaMacCommand.cpp LoRaMacCommand.h LoRaMacCrypto.cpp LoRaMacCrypto.h
    ./mbed-os/connectivity/lorawan/include/lorawan/: LoRaRadio.h lorawan_types.h LoRaWANBase.h LoRaWANInterface.h LoRaWANStack.h
    ./mbed-os/connectivity/lorawan/system/: lorawan_data_structures.h LoRaWANTimer.cpp LoRaWANTimer.h
    ./mbed-os/connectivity/lorawan/source/: LoRaWANInterface.cpp LoRaWANStack.cpp
    ./mbed-os/connectivity/nanostack/mbed-mesh-api/mbed-mesh-api/: LoWPANNDInterface.h mesh_interface_types.h MeshInterfaceNanostack.h NanostackEthernetInterface.h NanostackPPPInterface.h ThreadInterface.h WisunBorderRouter.h WisunInterface.h
    ./mbed-os/hal/source/: LowPowerTickerWrapper.cpp mbed_compat.c mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_gpio_irq.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_pinmap_default.cpp mbed_ticker_api.c mbed_us_ticker_api.c static_pinmap.cpp
    ./mbed-os/connectivity/lwipstack/lwip/src/core/: lwip_altcp.c lwip_altcp_alloc.c lwip_altcp_tcp.c lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
    ./mbed-os/connectivity/lwipstack/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_if_api.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
    ./mbed-os/connectivity/lwipstack/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
    ./mbed-os/connectivity/lwipstack/lwip/src/netif/: lwip_bridgeif.c lwip_bridgeif_fdb.c lwip_ethernet.c lwip_lowpan6.c lwip_lowpan6_ble.c lwip_lowpan6_common.c lwip_zepif.c
    ./mbed-os/connectivity/lwipstack/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
    ./mbed-os/connectivity/lwipstack/lwip-sys/: lwip_random.c lwip_random.h lwip_tcp_isn.c lwip_tcp_isn.h
    ./mbed-os/connectivity/lwipstack/source/: lwip_tools.cpp LWIPInterface.cpp LWIPInterfaceEMAC.cpp LWIPInterfaceL3IP.cpp LWIPInterfacePPP.cpp LWIPMemoryManager.cpp LWIPStack.cpp
    ./mbed-os/connectivity/lwipstack/include/lwipstack/: lwip_tools.h LWIPMemoryManager.h lwipopts.h LWIPStack.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/IEEE802_15_4/: mac_cca_threshold.c mac_cca_threshold.h mac_data_buffer.h mac_defines.h mac_fhss_callbacks.c mac_fhss_callbacks.h mac_filter.c mac_filter.h mac_header_helper_functions.c mac_header_helper_functions.h mac_indirect_data.c mac_indirect_data.h mac_mcps_sap.c mac_mcps_sap.h mac_mlme.c mac_mlme.h mac_mode_switch.c mac_mode_switch.h mac_pd_sap.c mac_pd_sap.h mac_security_mib.c mac_security_mib.h mac_timer.c mac_timer.h sw_mac.c sw_mac_internal.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mac_neighbor_table/: mac_neighbor_table.c mac_neighbor_table.h
    ./mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    ./mbed-os/: mbed.h
    ./mbed-os/cmsis/device/rtos/source/: mbed_boot.c mbed_rtos_rtx.c mbed_rtx_handlers.c mbed_rtx_idle.cpp
    ./mbed-os/cmsis/device/rtos/include/: mbed_boot.h mbed_rtx_conf.h mbed_rtx_storage.h
    ./mbed-os/cmsis/device/rtos/TOOLCHAIN_ARM_STD/: mbed_boot_arm_std.c
    ./mbed-os/cmsis/device/: mbed_cmsis_conf.h
    ./mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.c
    ./mbed-os/features/frameworks/mbed-greentea-io/: mbed_io.cpp
    ./mbed-os/hal/source/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    ./mbed-os/platform/source/minimal-printf/: mbed_printf_armlink_overrides.c mbed_printf_implementation.c mbed_printf_implementation.h mbed_printf_wrapper.c
    ./mbed-os/rtos/include/rtos/internal/: mbed_rtos1_types.h mbed_rtos_storage.h
    ./mbed-os/platform/mbed-trace/source/: mbed_trace.c
    ./mbed-os/platform/mbed-trace/include/mbed-trace/: mbed_trace.h ns_trace.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Source/: mbed_tz_context.c
    ./mbed-os/hal/usb/source/: mbed_usb_phy.cpp
    ./mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver/source/: MCR20Drv.c MCR20Drv.h MCR20Overwrites.h MCR20Reg.h NanostackRfPhyMcr20a.cpp XcvrSpi.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Mesh/: mesh.c mesh.h
    ./mbed-os/connectivity/nfc/source/ndef/: MessageBuilder.cpp MessageParser.cpp RecordParser.cpp
    ./mbed-os/connectivity/nfc/include/nfc/ndef/: MessageBuilder.h MessageParser.h Record.h RecordParser.h
    ./mbed-os/connectivity/nfc/source/ndef/common/: Mime.cpp SimpleMessageParser.cpp Text.cpp URI.cpp util.cpp
    ./mbed-os/connectivity/nfc/include/nfc/ndef/common/: Mime.h SimpleMessageParser.h Text.h URI.h util.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MLE/: mle.c mle.h mle_tlv.c mle_tlv.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/mle_service/: mle_service.c mle_service_api.h mle_service_buffer.c mle_service_buffer.h mle_service_frame_counter_table.c mle_service_frame_counter_table.h mle_service_interface.c mle_service_interface.h mle_service_security.c mle_service_security.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MPL/: mpl.c mpl.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/msg_sec_prot/: msg_sec_prot.c msg_sec_prot.h
    ./mbed-os/platform/cxxsupport/: mstd_mutex.cpp
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/libNET/src/: multicast_api.c net_6lowpan_parameter_api.c net_dns.c net_dns_internal.h net_ipv6.c net_load_balance.c net_load_balance_internal.h net_mle.c net_rpl.c net_short_address_extension.c net_test.c ns_net.c socket_api.c
    ./mbed-os/connectivity/nanostack/source/: Nanostack.cpp
    ./mbed-os/connectivity/nanostack/include/nanostack-interface/: Nanostack.h NanostackEthernetPhy.h NanostackInterface.h NanostackLockGuard.h NanostackMACPhy.h NanostackPhy.h NanostackPPPPhy.h NanostackRfPhy.h
    ./mbed-os/connectivity/drivers/802.15.4_RF/atmel-rf-driver/atmel-rf-driver/: NanostackRfPhyAtmel.h
    ./mbed-os/connectivity/drivers/802.15.4_RF/mcr20a-rf-driver/mcr20a-rf-driver/: NanostackRfPhyMcr20a.h
    ./mbed-os/connectivity/drivers/802.15.4_RF/stm-s2lp-rf-driver/stm-s2lp-rf-driver/: NanostackRfPhys2lp.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/ND/: nd_defines.h nd_router_object.c nd_router_object.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/nd_proxy/: nd_proxy.c nd_proxy.h
    ./mbed-os/connectivity/nfc/libraries/stack/ndef/: ndef.c ndef.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/Neighbor_cache/: neighbor_cache.c neighbor_table_definition.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/: netdb.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/Generic/: network_lib.c protocol_6lowpan.c protocol_6lowpan_bootstrap.c protocol_6lowpan_interface.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/: network_lib.h protocol_6lowpan.h protocol_6lowpan_bootstrap.h protocol_6lowpan_interface.h
    ./mbed-os/connectivity/nfc/include/nfc/: NFC.h NFCController.h NFCControllerDriver.h NFCDefinitions.h NFCEEPROM.h NFCEEPROMDriver.h NFCNDEFCapable.h NFCRemoteEndpoint.h NFCRemoteInitiator.h NFCTarget.h Type4RemoteInitiator.h
    ./mbed-os/connectivity/nfc/libraries/stack/: nfc_common.h nfc_errors.h
    ./mbed-os/connectivity/nfc/libraries/stack/platform/: nfc_debug.h nfc_scheduler.c nfc_scheduler.h nfc_transport.c nfc_transport.h
    ./mbed-os/connectivity/nfc/source/: NFCController.cpp NFCControllerDriver.cpp NFCEEPROM.cpp NFCEEPROMDriver.cpp NFCNDEFCapable.cpp NFCRemoteEndpoint.cpp NFCRemoteInitiator.cpp NFCTarget.cpp Type4RemoteInitiator.cpp
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/nist_aes_kw/: nist_aes_kw.c nist_aes_kw.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Core/include/: ns_address_internal.h ns_buffer.h ns_error_types.h ns_monitor.h ns_socket.h sockbuf.h
    ./mbed-os/features/frameworks/mbed-client-cli/source/: ns_cmdline.c
    ./mbed-os/features/frameworks/mbed-client-cli/mbed-client-cli/: ns_cmdline.h
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/libList/: ns_list.c
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/SHA256_Lib/: ns_sha256.c shalib.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/: nsconfig.h
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/nsdynmemtracker/: nsdynmem_tracker_lib.c
    ./mbed-os/connectivity/libraries/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
    ./mbed-os/connectivity/nanostack/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/NVM/: nwk_nvm.c nwk_nvm.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/Source/: os_systick.c os_tick_ptim.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/pan_blacklist/: pan_blacklist.c pan_blacklist_api.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TARGET_NUCLEO_L476RG/: PeripheralPins.c PinNames.h
    ./mbed-os/connectivity/mbedtls/platform/inc/: platform_alt.h platform_mbed.h shared_rng.h timing_alt.h
    ./mbed-os/storage/platform/source/: PlatformStorage.cpp
    ./mbed-os/connectivity/drivers/nfc/PN512/source/transceiver/: pn512.c pn512.h pn512_callback.h pn512_cmd.c pn512_cmd.h pn512_hw.c pn512_hw.h pn512_internal.h pn512_irq.c pn512_irq.h pn512_poll.c pn512_poll.h pn512_registers.c pn512_registers.h pn512_rf.c pn512_rf.h pn512_timer.c pn512_timer.h pn512_transceive.c pn512_transceive.h pn512_types.h
    ./mbed-os/connectivity/drivers/nfc/PN512/source/: PN512Driver.cpp PN512SPITransportDriver.cpp PN512TransportDriver.cpp
    ./mbed-os/connectivity/drivers/nfc/PN512/include/nfc/controllers/: PN512Driver.h PN512SPITransportDriver.h PN512TransportDriver.h
    ./mbed-os/connectivity/libraries/ppp/source/polarssl/: ppp_arc4.c ppp_des.c ppp_md4.c ppp_md5.c ppp_sha1.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/Include/: protocol.h protocol_abstract.h protocol_stats.h protocol_timer.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/: protocol_core.c protocol_core_sleep.c protocol_stats.c protocol_timer.c
    ./mbed-os/connectivity/nfc/libraries/stack/transceiver/: protocols.h transceiver.c transceiver.h transceiver_internal.h
    ./mbed-os/connectivity/drivers/cellular/QUECTEL/BC95/: QUECTEL_BC95.cpp QUECTEL_BC95.h QUECTEL_BC95_CellularContext.cpp QUECTEL_BC95_CellularContext.h QUECTEL_BC95_CellularInformation.cpp QUECTEL_BC95_CellularInformation.h QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularStack.h
    ./mbed-os/connectivity/drivers/cellular/QUECTEL/BG96/: QUECTEL_BG96.cpp QUECTEL_BG96.h QUECTEL_BG96_CellularContext.cpp QUECTEL_BG96_CellularContext.h QUECTEL_BG96_CellularInformation.cpp QUECTEL_BG96_CellularInformation.h QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularStack.cpp QUECTEL_BG96_CellularStack.h QUECTEL_BG96_ControlPlane_netif.cpp QUECTEL_BG96_ControlPlane_netif.h
    ./mbed-os/connectivity/drivers/cellular/QUECTEL/EC2X/: QUECTEL_EC2X.cpp QUECTEL_EC2X.h
    ./mbed-os/connectivity/drivers/cellular/QUECTEL/M26/: QUECTEL_M26.cpp QUECTEL_M26.h QUECTEL_M26_CellularContext.cpp QUECTEL_M26_CellularContext.h QUECTEL_M26_CellularInformation.cpp QUECTEL_M26_CellularInformation.h QUECTEL_M26_CellularStack.cpp QUECTEL_M26_CellularStack.h
    ./mbed-os/connectivity/drivers/cellular/QUECTEL/UG96/: QUECTEL_UG96.cpp QUECTEL_UG96.h QUECTEL_UG96_CellularContext.cpp QUECTEL_UG96_CellularContext.h
    ./mbed-os/platform/randlib/source/: randLIB.c
    ./mbed-os/platform/randlib/include/mbed-client-randlib/: randLIB.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/random_early_detection/: random_early_detection.c random_early_detection.h random_early_detection_api.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/: rf_driver_storage.c rf_driver_storage.h
    ./mbed-os/connectivity/drivers/cellular/RiotMicro/AT/: RM1000_AT.cpp RM1000_AT.h RM1000_AT_CellularContext.cpp RM1000_AT_CellularContext.h RM1000_AT_CellularNetwork.cpp RM1000_AT_CellularNetwork.h RM1000_AT_CellularStack.cpp RM1000_AT_CellularStack.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/RPL/: rpl_control.c rpl_control.h rpl_data.c rpl_data.h rpl_downward.c rpl_downward.h rpl_mrhof.c rpl_mrhof.h rpl_objective.c rpl_objective.h rpl_of0.c rpl_of0.h rpl_policy.c rpl_policy.h rpl_protocol.h rpl_structures.h rpl_upward.c rpl_upward.h
    ./mbed-os/cmsis/device/RTE/include/: RTE_Components.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ./mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include/: rtx_def.h rtx_evr.h rtx_os.h
    ./mbed-os/connectivity/drivers/cellular/MultiTech/DragonflyNano/PPP/: SARA4_PPP.cpp SARA4_PPP.h SARA4_PPP_CellularNetwork.cpp SARA4_PPP_CellularNetwork.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/Common/: sec_lib.h sec_lib_definitions.h security_lib.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/: sec_prot.h sec_prot_certs.c sec_prot_certs.h sec_prot_cfg.h sec_prot_keys.c sec_prot_keys.h sec_prot_lib.c sec_prot_lib.h
    ./mbed-os/storage/kvstore/securestore/source/: SecureStore.cpp
    ./mbed-os/storage/kvstore/securestore/include/securestore/: SecureStore.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/serial/: serial_mac_api.c
    ./mbed-os/storage/blockdevice/include/blockdevice/internal/: SFDP.h
    ./mbed-os/connectivity/libraries/mbed-coap/source/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ./mbed-os/connectivity/libraries/mbed-coap/mbed-coap/: sn_coap_header.h sn_coap_protocol.h sn_config.h
    ./mbed-os/connectivity/libraries/mbed-coap/source/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    ./mbed-os/connectivity/lwipstack/lwip/src/include/compat/posix/sys/: socket.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/TARGET_STM32L476xG/TOOLCHAIN_ARM/: startup_stm32l476xx.S
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/Legacy/: stm32_hal_legacy.h stm32l4xx_hal_can_legacy.c stm32l4xx_hal_can_legacy.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/CMSIS/: stm32l412xx.h stm32l422xx.h stm32l431xx.h stm32l432xx.h stm32l433xx.h stm32l442xx.h stm32l443xx.h stm32l451xx.h stm32l452xx.h stm32l462xx.h stm32l471xx.h stm32l475xx.h stm32l476xx.h stm32l485xx.h stm32l486xx.h stm32l496xx.h stm32l4a6xx.h stm32l4p5xx.h stm32l4q5xx.h stm32l4r5xx.h stm32l4r7xx.h stm32l4r9xx.h stm32l4s5xx.h stm32l4s7xx.h stm32l4s9xx.h stm32l4xx.h system_stm32l4xx.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/STM32L4xx_HAL_Driver/: stm32l4xx_hal.c stm32l4xx_hal.h stm32l4xx_hal_adc.c stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.c stm32l4xx_hal_can.h stm32l4xx_hal_comp.c stm32l4xx_hal_comp.h stm32l4xx_hal_cortex.c stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.c stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.c stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.c stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.c stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dma.c stm32l4xx_hal_dma.h stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma2d.h stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dsi.c stm32l4xx_hal_dsi.h stm32l4xx_hal_exti.c stm32l4xx_hal_exti.h stm32l4xx_hal_firewall.c stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.c stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gpio.c stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.c stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.c stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.c stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.c stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.c stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.c stm32l4xx_hal_lptim.h stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc.h stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_mmc_ex.h stm32l4xx_hal_nand.c stm32l4xx_hal_nand.h stm32l4xx_hal_nor.c stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_ospi.c stm32l4xx_hal_ospi.h stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pka.c stm32l4xx_hal_pka.h stm32l4xx_hal_pssi.c stm32l4xx_hal_pssi.h stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.c stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.c stm32l4xx_hal_rng.h stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rng_ex.h stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.c stm32l4xx_hal_sai.h stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sd.c stm32l4xx_hal_sd.h stm32l4xx_hal_sd_ex.c stm32l4xx_hal_sd_ex.h stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.c stm32l4xx_hal_smbus.h stm32l4xx_hal_smbus_ex.c stm32l4xx_hal_smbus_ex.h stm32l4xx_hal_spi.c stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.c stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.c stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.c stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.c stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.c stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.c stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.c stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.c stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.c stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.c stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.c stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.c stm32l4xx_ll_crc.h stm32l4xx_ll_crs.c stm32l4xx_ll_crs.h stm32l4xx_ll_dac.c stm32l4xx_ll_dac.h stm32l4xx_ll_dma.c stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.c stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.c stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.c stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.c stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.c stm32l4xx_ll_opamp.h stm32l4xx_ll_pka.c stm32l4xx_ll_pka.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.c stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.c stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.c stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.c stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.c stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.c stm32l4xx_ll_tim.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_usb.c stm32l4xx_ll_usb.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
    ./mbed-os/targets/TARGET_STM/TARGET_STM32L4/STM32Cube_FW/: stm32l4xx_hal_conf.h system_stm32l4xx.c
    ./mbed-os/connectivity/drivers/emac/TARGET_STM/: stm32xx_emac.cpp stm32xx_emac.h stm32xx_eth_irq_callback.cpp
    ./mbed-os/storage/kvstore/tdbstore/source/: TDBStore.cpp
    ./mbed-os/storage/kvstore/tdbstore/include/tdbstore/: TDBStore.h
    ./mbed-os/connectivity/drivers/cellular/TELIT/HE910/: TELIT_HE910.cpp TELIT_HE910.h
    ./mbed-os/connectivity/drivers/cellular/TELIT/ME310/: TELIT_ME310.cpp TELIT_ME310.h TELIT_ME310_CellularContext.cpp TELIT_ME310_CellularContext.h TELIT_ME310_CellularNetwork.cpp TELIT_ME310_CellularNetwork.h TELIT_ME310_CellularStack.cpp TELIT_ME310_CellularStack.h
    ./mbed-os/connectivity/drivers/cellular/TELIT/ME910/: TELIT_ME910.cpp TELIT_ME910.h TELIT_ME910_CellularContext.cpp TELIT_ME910_CellularContext.h TELIT_ME910_CellularNetwork.cpp TELIT_ME910_CellularNetwork.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/Thread/: thread_bbr_api.c thread_bbr_api_internal.h thread_bbr_commercial.c thread_bbr_commercial.h thread_beacon.c thread_beacon.h thread_bootstrap.c thread_bootstrap.h thread_border_router_api.c thread_border_router_api_internal.h thread_ccm.c thread_ccm.h thread_commissioning_api.c thread_commissioning_if.c thread_commissioning_if.h thread_common.c thread_common.h thread_config.h thread_constants.h thread_dhcpv6_server.c thread_dhcpv6_server.h thread_diagnostic.c thread_diagnostic.h thread_discovery.c thread_discovery.h thread_host_bootstrap.c thread_host_bootstrap.h thread_joiner_application.c thread_joiner_application.h thread_leader_service.c thread_leader_service.h thread_lowpower_api.c thread_lowpower_private_api.c thread_lowpower_private_api.h thread_management_api.c thread_management_client.c thread_management_client.h thread_management_if.c thread_management_internal.h thread_management_server.c thread_management_server.h thread_mdns.c thread_mdns.h thread_meshcop_lib.c thread_mle_message_handler.c thread_mle_message_handler.h thread_nd.c thread_nd.h thread_neighbor_class.c thread_neighbor_class.h thread_net_config_api.c thread_network_data_lib.c thread_network_data_lib.h thread_network_data_storage.c thread_network_data_storage.h thread_network_synch.c thread_network_synch.h thread_nvm_store.c thread_nvm_store.h thread_resolution_client.c thread_resolution_client.h thread_resolution_server.c thread_resolution_server.h thread_router_bootstrap.c thread_router_bootstrap.h thread_routing.c thread_routing.h thread_test_api.c thread_tmfcop_lib.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/TLS/: tls_ccm_crypt.c tls_ccm_crypt.h tls_lib.c tls_lib.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Security/protocols/tls_sec_prot/: tls_sec_prot.c tls_sec_prot.h tls_sec_prot_lib.c tls_sec_prot_lib.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/Trickle/: trickle.c trickle.h
    ./mbed-os/connectivity/nfc/libraries/stack/tech/type4/: type4_target.c type4_target.h
    ./mbed-os/connectivity/drivers/cellular/UBLOX/AT/: UBLOX_AT.cpp UBLOX_AT.h UBLOX_AT_CellularContext.cpp UBLOX_AT_CellularContext.h UBLOX_AT_CellularNetwork.cpp UBLOX_AT_CellularNetwork.h UBLOX_AT_CellularStack.cpp UBLOX_AT_CellularStack.h
    ./mbed-os/connectivity/drivers/cellular/UBLOX/N2XX/: UBLOX_N2XX.cpp UBLOX_N2XX.h UBLOX_N2XX_CellularContext.cpp UBLOX_N2XX_CellularContext.h UBLOX_N2XX_CellularNetwork.cpp UBLOX_N2XX_CellularNetwork.h UBLOX_N2XX_CellularSMS.cpp UBLOX_N2XX_CellularSMS.h UBLOX_N2XX_CellularStack.cpp UBLOX_N2XX_CellularStack.h
    ./mbed-os/connectivity/drivers/cellular/UBLOX/PPP/: UBLOX_PPP.cpp UBLOX_PPP.h
    ./mbed-os/features/frameworks/unity/source/: unity.c
    ./mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    ./mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_print.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    ./mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_print.h utest_scheduler.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    ./mbed-os/hal/usb/include/usb/: usb_phy_api.h USBPhy.h USBPhyEvents.h USBPhyTypes.h
    ./mbed-os/drivers/usb/include/usb/: USBAudio.h USBCDC.h USBCDC_ECM.h USBHID.h USBKeyboard.h USBMIDI.h USBMouse.h USBMouseKeyboard.h USBMSD.h USBSerial.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/MAC/virtual_rf/: virtual_rf_client.c virtual_rf_defines.h virtual_rf_driver.c
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/Service_Libs/whiteboard/: whiteboard.c whiteboard.h
    ./mbed-os/connectivity/nanostack/sal-stack-nanostack/source/6LoWPAN/ws/: ws_bbr_api.c ws_bbr_api_internal.h ws_bootstrap.c ws_bootstrap.h ws_bootstrap_6lbr.c ws_bootstrap_6lbr.h ws_bootstrap_6ln.c ws_bootstrap_6ln.h ws_bootstrap_6lr.c ws_bootstrap_6lr.h ws_bootstrap_ffn.c ws_bootstrap_ffn.h ws_cfg_settings.c ws_cfg_settings.h ws_common.c ws_common.h ws_common_defines.h ws_config.h ws_eapol_auth_relay.c ws_eapol_auth_relay.h ws_eapol_pdu.c ws_eapol_pdu.h ws_eapol_relay.c ws_eapol_relay.h ws_eapol_relay_lib.c ws_eapol_relay_lib.h ws_empty_functions.c ws_ie_lib.c ws_ie_lib.h ws_llc.h ws_llc_data_service.c ws_management_api.c ws_mpx_header.c ws_mpx_header.h ws_neighbor_class.c ws_neighbor_class.h ws_pae_auth.c ws_pae_auth.h ws_pae_controller.c ws_pae_controller.h ws_pae_key_storage.c ws_pae_key_storage.h ws_pae_lib.c ws_pae_lib.h ws_pae_nvm_data.c ws_pae_nvm_data.h ws_pae_nvm_store.c ws_pae_nvm_store.h ws_pae_supp.c ws_pae_supp.h ws_pae_time.c ws_pae_time.h ws_pae_timers.c ws_pae_timers.h ws_phy.c ws_phy.h ws_stats.c ws_stats.h ws_test_api.c
  group XJEL2645Unit4
    ./: mbed_config.h
  group Thirdparty/CMSIS_Math
    ./Thirdparty/CMSIS_Math/Source/BasicMathFunctions/: arm_abs_f32.c arm_add_f32.c arm_dot_prod_f32.c arm_mult_f32.c arm_negate_f32.c arm_offset_f32.c arm_scale_f32.c arm_sub_f32.c
    ./Thirdparty/CMSIS_Math/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ./Thirdparty/CMSIS_Math/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_dot_prod_f32.c arm_cmplx_mag_f32.c arm_cmplx_mag_squared_f32.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_real_f32.c
    ./Thirdparty/CMSIS_Math/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_reset_f32.c arm_sin_cos_f32.c
    ./Thirdparty/CMSIS_Math/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ./Thirdparty/CMSIS_Math/Source/FilteringFunctions/: arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_partial_f32.c arm_correlate_f32.c arm_fir_decimate_f32.c arm_fir_decimate_init_f32.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_f32.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_lms_f32.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c
    ./Thirdparty/CMSIS_Math/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ./Thirdparty/CMSIS_Math/Source/StatisticsFunctions/: arm_max_f32.c arm_mean_f32.c arm_min_f32.c arm_power_f32.c arm_rms_f32.c arm_std_f32.c arm_var_f32.c
    ./Thirdparty/CMSIS_Math/Source/SupportFunctions/: arm_copy_f32.c arm_fill_f32.c
    ./Thirdparty/CMSIS_Math/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_cfft_f32.c arm_cfft_radix2_f32.c arm_cfft_radix4_f32.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_cfft_radix4_init_f32.c
  group Thirdparty/MatrixLibrary
    ./Thirdparty/MatrixLibrary/: matrix.cpp
